Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Sunbed - ver4.ifc
Time: 2024-10-24T16:52:49
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (6)
Name
 | Nalu-Sunbed_0 - ObjectType: SketchupGroup
 | Nalu-Sunbed_1 - ObjectType: SketchupGroup
 | Nalu-Sunbed_2 - ObjectType: SketchupGroup
 | Nalu-Sunbed_3 - ObjectType: SketchupGroup
 | Nalu-Sunbed_4 - ObjectType: SketchupGroup
 | Nalu-Sunbed_5 - ObjectType: SketchupGroup
